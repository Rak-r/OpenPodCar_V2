Commit message: add description for optical flow sensor

File: src/pod2_description/xacro/OpenPodCar_V2_Depth.urdf (robot description, URDF)
Before this commit: robot podcar, 9 links, 8 joints
Joints:
- joint camera_joint: origin xyz=+0.8 0 0.68 rpy=0 0 -0.7854 -> xyz=+0.845 0 +0.64 rpy=0.0 0. 0
